# Keil uVision project Project_52241_IAP.uvprojx, settings and files
target IAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F52241 Holtek
  pack: Holtek.HT32_DFP.1.0.20
  cpu: IROM(0x00000000-0x0000FBFF) IRAM(0x20000000-0x20001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: IAP +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52241_SK, USE_HT32F52231_41, USE_MEM_HT32F52241
  c include: ..\Src_IAP;..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\..\library\HT32F5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities;..\OTA\INC;..\Source\main_callfun\inc;..\AP_FLASH
  asm define: USE_HT32_CHIP=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group User
    ../Src_IAP/: iap_main.c iap_ht32f5xxxx_01_it.c iap_handler.c iap_xmodem.c iap_buffer.c iap_crc16.c
    ../Source/main_callfun/src/: main_callfun.c flash_copy.c
  group Config
    ../Src_IAP/: ht32f5xxxx_conf.h
    ./: HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../Src_IAP/: iap_system_ht32f5xxxx_02.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01_iap.s
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_crc.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_mctm.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
